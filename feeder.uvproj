# Keil uVision project feeder.uvproj, settings and files
target stc8f2k08s2 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: feeder +hex
  c flags: Optimize=8 SizeSpeed=1
  asm include: .\bsp;.\drivers;.\app
  group startups
    ./: STARTUP.A51
  group drivers
    ./drivers/: led.c
  group app
    ./app/: main.c
